options:
  parameters:
    generate_options: qt_gui
    id: waterfall
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: LO Mixer frequency
    start: '0'
    step: '1'
    stop: 200000000/16
    value: '0'
  states: {}
- name: mode
  id: variable_qtgui_range
  parameters:
    label: SDR output mode
    rangeType: int
    start: '0'
    step: '1'
    stop: '2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400000000/512
  states: {}
- name: zone
  id: variable_qtgui_range
  parameters:
    label: Fir center
    start: '0'
    step: '1'
    stop: '200000000'
    value: '50000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: +1 +1j
    type: complex
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import sys
      import numpy as np
      import threading
      from gnuradio import gr
      import socket



      class ExampleBlock(gr.sync_block):
          def __init__(self, mode=0, frequency=0, zone=1.0):
              # Initialize the block with no inputs and one complex 8-bit output
              gr.sync_block.__init__(
                  self,
                  name="ExampleBlock",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              # Initialize settings with default values
              self.mode = mode
              self.last_mode = -1
              self.frequency = frequency
              self.last_frequency = -1
              self.zone = zone
              self.last_zone = -1
              self.send_message("localhost", 2010, "{" + f'"cmd": "freq", "frequency":{self.frequency}' + "}")

              print("Blarg")

          def async_message(self, server_ip, server_port, message):
              threading.Thread(target=self.send_message, args=(server_ip, server_port, message)).start()

          def send_message(self, server_ip, server_port, message):
              with socket.socket(socket.AF_INET, socket.SOCK_STREAM) as s:
                  s.connect((server_ip, server_port))
                  s.sendall(message.encode())

          def work(self, input_items, output_items):
              out = output_items[0]

              if self.last_mode != self.mode:
                  self.last_mode = self.mode
                  self.async_message("localhost", 2010, "{" + f'"cmd": "mode", "mode":{self.mode}' + "}")

              if self.last_frequency != self.frequency:
                  self.last_frequency = self.frequency
                  self.async_message("localhost", 2010, "{" + f'"cmd": "freq", "frequency":{self.frequency}' + "}")

              if self.last_zone != self.zone:
                  self.last_zone = self.zone
                  self.async_message("localhost", 2010, "{" + f'"cmd": "filter", "zone":{self.zone}' + "}")

              out[:] = input_items[0][:]

              return len(out)
    frequency: frequency
    mode: mode
    zone: ((zone-12500000)/25000000)
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2001'
    server: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0_0, '0']
- [analog_const_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_0_0, '0', epy_block_0, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_add_xx_0_0, '1']
- [blocks_stream_demux_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_demux_0, '1', blocks_char_to_float_0_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0, '0']
- [network_tcp_source_0, '0', blocks_stream_demux_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
