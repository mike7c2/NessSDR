options:
  parameters:
    generate_options: qt_gui
    id: lime
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: LO Mixer frequency
    start: '0'
    step: '1'
    stop: 200000000/16
    value: '0'
  states: {}
- name: mode
  id: variable_qtgui_range
  parameters:
    label: SDR output mode
    rangeType: int
    start: '0'
    step: '1'
    stop: '1'
    value: '0'
  states: {}
- name: noise_mag
  id: variable_qtgui_range
  parameters:
    label: Noise magnitude
    start: '0'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    label: TX LO frequency
    start: '20000000'
    step: '100000'
    stop: '1000000000'
    value: '20000000'
  states: {}
- name: rf_pwr
  id: variable_qtgui_range
  parameters:
    label: TX Power
    start: '-20'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '60000000'
  states: {}
- name: sig_freq
  id: variable_qtgui_range
  parameters:
    label: TX signal frequency offset
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '50'
  states: {}
- name: tone_mag
  id: variable_qtgui_range
  parameters:
    label: Tone magnitude
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.5'
  states: {}
- name: zone
  id: variable_qtgui_range
  parameters:
    label: Fir center
    start: '0'
    step: '1'
    stop: '200000000'
    value: '50000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: +1 +1j
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_mag
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: tone_mag
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import sys
      import numpy as np
      import threading
      from gnuradio import gr
      import socket



      class ExampleBlock(gr.sync_block):
          def __init__(self, mode=0, frequency=0, zone=1.0):
              # Initialize the block with no inputs and one complex 8-bit output
              gr.sync_block.__init__(
                  self,
                  name="ExampleBlock",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              # Initialize settings with default values
              self.mode = mode
              self.last_mode = -1
              self.frequency = frequency
              self.last_frequency = -1
              self.zone = zone
              self.last_zone = -1
              self.send_message("localhost", 2010, "{" + f'"cmd": "freq", "frequency":{self.frequency}' + "}")

              print("Blarg")

          def async_message(self, server_ip, server_port, message):
              threading.Thread(target=self.send_message, args=(server_ip, server_port, message)).start()

          def send_message(self, server_ip, server_port, message):
              with socket.socket(socket.AF_INET, socket.SOCK_STREAM) as s:
                  s.connect((server_ip, server_port))
                  s.sendall(message.encode())

          def work(self, input_items, output_items):
              out = output_items[0]

              if self.last_mode != self.mode:
                  self.last_mode = self.mode
                  self.async_message("localhost", 2010, "{" + f'"cmd": "mode", "mode":{self.mode}' + "}")

              if self.last_frequency != self.frequency:
                  self.last_frequency = self.frequency
                  self.async_message("localhost", 2010, "{" + f'"cmd": "freq", "frequency":{self.frequency}' + "}")

              if self.last_zone != self.zone:
                  self.last_zone = self.zone
                  self.async_message("localhost", 2010, "{" + f'"cmd": "filter", "zone":{self.zone}' + "}")

              out[:] = input_items[0][:]

              return len(out)
    frequency: frequency
    mode: mode
    zone: zone/12500000
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '2001'
    server: 'False'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: '200000'
    center_freq: rf_freq
    gain: rf_pwr
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: '60000000'
    center_freq: rf_freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0_0, '0']
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0_1_0, '0']
- [blocks_add_xx_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_add_xx_0_0, '0', epy_block_0, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_add_xx_0_0, '1']
- [blocks_stream_demux_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_demux_0, '1', blocks_char_to_float_0_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_waterfall_sink_x_0, '0']
- [network_tcp_source_0, '0', blocks_stream_demux_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_waterfall_sink_x_0_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
